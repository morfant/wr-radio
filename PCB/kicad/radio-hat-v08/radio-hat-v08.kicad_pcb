# Repository morfant/wr-radio

File README.md:

# WR-Radio

## 설정 방법

### 1. 첫 실행
```bash
python3 wr-radio.py
```
첫 실행 시 `config.json` 파일이 자동 생성됩니다.

### 2. 스테이션 추가/변경
```bash
nano ~/wr-radio/config.json
```
```json
{
  "stations": [
    {
      "name": "내가 좋아하는 라디오",
      "url": "http://stream-url.mp3",
      "location": "Seoul, Korea",
      "lat": 37.5665,
      "lon": 126.9780,
      "color": [255, 100, 100]
    }
  ]
}
```

### 3. 날씨 기능 (선택)
1. https://openweathermap.org/appid 에서 무료 API 키 발급
2. `config.json`에 키 입력:
```json
   {
     "openweather_api_key": "여기에_키_입력"
   }
```

## KiCad design PCB/kicad/radio-hat-v08/radio-hat-v08.kicad_pcb

Parts:
C1, C2, C3, C5, C15, C21: 10uF; C_0805_2012Metric; MPN CL21A106KAYNNNE; LCSC C15850
C4, C11, C12, C13, C14, C22: 0.1uF; C_0603_1608Metric; MPN CC0603KRX7R9BB104; LCSC C14663
C6, C7, C25, C27: 22uF; C_0805_2012Metric; MPN CL21A226MAQNNNE; LCSC C45783
C8: 220uF; CP_Elec_6.3x7.7; MPN RVT1C221M0607; LCSC C970695
C9, C10: 100nF; C_0603_1608Metric; MPN CC0603KRX7R9BB104; LCSC C14663
C16, C17, C18: 2.2uF; C_0603_1608Metric; MPN CL10A225KO8NNNC; LCSC C23630
C19, C20: 2.2nF; C_0603_1608Metric; MPN 0603B222K500NT; LCSC C1604
C23, C24, C26: 330pF; C_0603_1608Metric; MPN CL10C331JB8NNNC; LCSC C1664
D1: SS34; D_SMA; MPN SS34; LCSC C8678
D2: BLUE; LED_XINGLIGHT_XL-1606_Horizontal; MPN XL-1606UBC; LCSC C965865
D3: GREEN; LED_XINGLIGHT_XL-1606_Horizontal; MPN XL-1606UGC; LCSC C965863
D4: SMAJ5.0A; D_SMA; MPN SMAJ5.0A; LCSC C2925443
FB1, FB2: FerriteBead; L_0805_2012Metric; MPN BLM21PG221SN1D; LCSC C85840
H1, H2, H3, H4, H5: MountingHole; MountingHole_2.7mm_M2.5
J1: Raspberry_Pi_40pin; PinHeader_2x20_P2.54mm_Horizontal_PiSide
J2: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_HRO_TYPE-C-31-M-12; MPN TYPE-C-31-M-12; LCSC C165948
J3: BAT; JST_XH_S2B-XH-A_1x02_P2.50mm_Horizontal; MPN S2B-XH-A(LF)(SN); LCSC C157931
J4: PWR_SW; PinHeader_1x03_P2.54mm_Horizontal; MPN PZ254R-11-03P; LCSC C492411
J5: LCD; PinHeader_1x08_P2.54mm_Horizontal; MPN PZ254R-11-08P; LCSC C492416
J6: ENC; PinHeader_1x05_P2.54mm_Horizontal; MPN PZ254R-11-05P; LCSC C492413
J7: SPK; PinHeader_1x02_P2.54mm_Horizontal; MPN PZ254R-11-02P; LCSC C492410
J8: PJ-307C; Jack_3.5mm_PJ-307C_Horizontal; MPN PJ-307C; LCSC C16684
J9: UART_DBG; PinHeader_1x03_P2.54mm_Vertical; not fitted
J10: BTN_EXT; PinHeader_1x02_P2.54mm_Vertical; not fitted
JP1: GAIN; SolderJumper-3_P1.3mm_Open_RoundedPad1.0x1.5mm
L1: 1uH; L_Changjiang_FXL0420; MPN FXL0420-1R0-MA1; LCSC C53426685
Q1: AO3401A; SOT-23; MPN AO3401A; LCSC C15127
Q2: 2N7002; SOT-23; MPN 2N7002; LCSC C8545
R1, R2: 5.1k; R_0603_1608Metric; MPN 0603WAF5101T5E; LCSC C23186
R3: 1.2k; R_0603_1608Metric; MPN 0603WAF1201T5E; LCSC C22765
R4, R5, R9: 1k; R_0603_1608Metric; MPN 0603WAF1001T5E; LCSC C21190
R6, R18, R21, R24: 10k; R_0603_1608Metric; MPN 0603WAF1002T5E; LCSC C25804
R7, R10, R13, R14, R15, R16, R17: 100k; R_0603_1608Metric; MPN 0603WAF1003T5E; LCSC C25803
R8, R19, R20: 100; R_0603_1608Metric; MPN 0603WAF1000T5E; LCSC C22775
R11: 510k; R_0603_1608Metric; MPN 0603WAF5103T5E; LCSC C23192
R12: 68k; R_0603_1608Metric; MPN 0603WAF6802T5E; LCSC C23231
R22: 1.8k; R_0603_1608Metric; MPN 0603WAF1801T5E; LCSC C4177
R23: 4.7k; R_0603_1608Metric; MPN 0603WAF4701T5E; LCSC C23162
U1: TP4056; SOIC-8-1EP_3.9x4.9mm_P1.27mm_EP2.41x3.3mm; MPN TP4056-42-ESOP8; LCSC C16581
U2: DW01A; SOT-23-6; MPN DW01A; LCSC C351410
U3: WSP8814; TSSOP-8_4.4x3mm_P0.65mm; MPN WSP8814; LCSC C148371
U4: TPS61023; SOT-563; MPN TPS61023DRLR; LCSC C919459
U5: ADS1115IDGS; TSSOP-10_3x3mm_P0.5mm; MPN ADS1115IDGSR; LCSC C37593
U6: PCM5102A; TSSOP-20_4.4x6.5mm_P0.65mm; MPN PCM5102APWR; LCSC C107671
U7: MAX98357A; TQFN-16-1EP_3x3mm_P0.5mm_EP1.23x1.23mm; MPN MAX98357AETE+T; LCSC C910544

Connections:
+3V3: C11.1, C12.1, C13.1, C14.1, C15.1, J1.1 (3V3), J1.17 (3V3), J6.1, R18.2, U5.8 (VDD), U6.1 (CPVDD), U6.8 (AVDD), U6.20 (DVDD)
+5V: C6.1, C7.1, C8.1, C21.1, C22.1, C26.1, J1.2 (5V), J1.4 (5V), J5.8, JP1.1 (A), R11.1, U4.6 (VOUT), U7.7 (VDD), U7.8 (VDD)
/AMP_OUTN: FB2.1, U7.10 (OUTN)
/AMP_OUTP: FB1.1, U7.9 (OUTP)
/AMP_SD: J1.18 (GPIO24/SDIO_DAT0), R21.1
/B-: C4.2, J3.2, U2.6 (GND), U3.2 (S1), U3.3 (S1)
/BAT+: C3.1, J3.1, Q1.3 (D), R8.1, R14.1, U1.5 (BAT)
/BST_EN: J4.2, R13.1, U4.2 (EN)
/BTN: J1.7 (GPCLK0/GPIO04), J10.1
/CAPM: C16.2, U6.4 (CAPM)
/CAPP: C16.1, U6.2 (CAPP)
/CC1: J2.A5 (CC1), R1.1
/CC2: J2.B5 (CC2), R2.1
/CHG_CE: Q2.3 (D), R6.1, U1.8 (CE)
/CHG_DIS: J1.22 (GPIO25/SDIO_DAT1), Q2.1 (G), R7.1
/CHRG_N: D2.1 (K), U1.7 (~CHRG)
/DAC_L: R19.1, U6.6 (OUTL)
/DAC_R: R20.1, U6.7 (OUTR)
/DW_CS: R9.1, U2.2 (CS)
/DW_VCC: C4.1, R8.2, U2.5 (VCC)
/ENC_KEY: J1.15 (GPIO22/SDIO_CLK), J6.2
/ENC_S1: J1.11 (GPIO17/SPI1_~CE1), J6.4
/ENC_S2: J1.13 (GPIO27/SDIO_DAT3), J6.3
/FB: C26.2, R11.2, R12.1, U4.1 (FB)
/FET_D: U3.1 (D1), U3.8 (D2)
/GAIN_SLOT: JP1.2 (C), U7.2 (GAIN_SLOT)
/HP_DET: C25.1, J1.16 (GPIO23/SDIO_CMD), R23.2
/HP_L: C19.1, J8.5 (T), R19.2
/HP_R: C20.1, J8.2 (R), R20.2
/HP_TN: J8.4 (TN), R23.1
/I2S_BCLK: J1.12 (GPIO18/SPI1_~CE0/PCM_CLK/PWM0), U6.13 (BCK), U7.16 (BCLK)
/I2S_DIN: J1.40 (GPIO21/SPI1_SCLK/PCM_DOUT), U6.14 (DIN), U7.1 (DIN)
/I2S_LRCLK: J1.35 (GPIO19/SPI1_MISO/PCM_FS), U6.15 (LRCK), U7.14 (LRCLK)
/LCD_BL: J1.32 (GPIO12/PWM0), J5.1
/LCD_CLK: J1.23 (SCLK_SPI0/GPIO11), J5.5
/LCD_CS: J1.37 (GPIO26/SDIO_DAT2), J5.4
/LCD_DC: J1.33 (GPIO13/PWM1), J5.3
/LCD_DIN: J1.19 (MOSI_SPI0/GPIO10), J5.6
/LCD_RST: J1.31 (GPCLK2/GPIO06), J5.2
/LDOO: C18.1, U6.18 (LDOO)
/LED_CHRG_A: D2.2 (A), R4.2
/LED_STDBY_A: D3.2 (A), R5.2
/OC: U2.3 (OC), U3.5 (G2)
/OD: U2.1 (OD), U3.4 (G1)
/PROG: R3.1, U1.2 (PROG)
/SCL: J1.5 (SCL_I2C1/GPIO03), U5.10 (SCL)
/SDA: J1.3 (SDA_I2C1/GPIO02), U5.9 (SDA)
/SD_MODE: R21.2, R22.1, U7.4 (~SD_MODE)
/SPK+: C23.1, FB1.2, J7.2
/SPK-: C24.1, FB2.2, J7.1
/STDBY_N: D3.1 (K), U1.6 (~STDBY)
/SW: L1.1, U4.5 (SW)
/SYS: C5.1, C27.1, D1.1 (K), J4.1, L1.2, Q1.2 (S), U4.3 (VIN)
/UART_RX: J1.10 (GPIO15/UART_RXD), J9.3
/UART_TX: J1.8 (GPIO14/UART_TXD), J9.2
/VBAT_SENSE: C9.1, R14.2, R15.1, U5.4 (AIN0)
/VBUS_SENSE: C10.1, R16.2, R17.1, U5.5 (AIN1)
/VNEG: C17.1, U6.5 (VNEG)
/XSMT: R18.1, U6.17 (XSMT)
GND: C1.2, C2.2, C3.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C27.2, D4.2 (A), J1.6 (GND), J1.9 (GND), J1.14 (GND), J1.20 (GND), J1.25 (GND), J1.30 (GND), J1.34 (GND), J1.39 (GND), J2.A1 (GND), J2.A12 (GND), J2.B1 (GND), J2.B12 (GND), J2.SH (SHIELD), J4.3, J5.7, J6.5, J8.1 (S), J9.1, J10.2, JP1.3 (B), Q2.2 (S), R1.2, R2.2, R3.2, R7.2, R9.2, R10.2, R12.2, R13.2, R15.2, R17.2, R22.2, R24.2, U1.1 (TEMP), U1.3 (GND), U1.9 (EPAD), U3.6 (S2), U3.7 (S2), U4.4 (GND), U5.1 (ADDR), U5.3 (GND), U6.3 (CPGND), U6.9 (AGND), U6.10 (DEMP), U6.11 (FLT), U6.12 (SCK), U6.16 (FMT), U6.19 (DGND), U7.3 (GND), U7.11 (GND), U7.15 (GND), U7.17 (PAD)
VBUS: C1.1, C2.1, D1.2 (A), D4.1 (K), J2.A4 (VBUS), J2.A9 (VBUS), J2.B4 (VBUS), J2.B9 (VBUS), Q1.1 (G), R4.1, R5.1, R6.2, R10.1, R16.1, R24.1, U1.4 (V_{CC})

Notes on the sheet:
USB-C input
J2 USB-C (sink, 5.1k CC pulldowns)
D4 (2026-11-08 2nd): VBUS TVS, K=VBUS A=GND
Charger TP4056 + charge inhibit
PROG 1.2k = ~1A (0.2C, >=5000mAh). GPIO25 CHG_DIS HIGH = charge OFF; LOW/float = ON
Load sharing
VBUS present: Q1 OFF, SYS from USB via D1
R24: VBUS pull-down vs SS34 leakage (2026-11-08 2nd)
Battery protection DW01A + WSP8814
B- = cell negative; system GND = P-. OC trip ~150mV / (2 x Rds): ~4.6-12 A
J3 JST XH 3A (2026-11-08 2nd): crimp the battery lead
with + on pin 1. NO reverse-polarity protection.
Boost 5V TPS61023
FB 510k/68k -> 5.06V, CFF C26 330pF (TI 8.2.2.4). J4 = power switch
Voltage sense ADS1115 (0x48)
A0 = BAT+/2, A1 = VBUS/2
Raspberry Pi 40-pin header
Right-angle 2x20 (Pi Zero 2W side-by-side)
Headphone DAC PCM5102A + jack
I2S slave, SCK=GND (PLL from BCK). Jack PJ-307C, insertion detect via tip NC switch (see note)
HP_DET (2026-11-08, 2nd): J8 pin 4 (tip NC) -4.7k- HP_DET
(GPIO23, Pi pin 16), 22uF to GND. No external pull-up:
the Pi internal pull-up is used, as the software does now.
No plug: tip touches pin 4, HP_DET sees the ground-centred DAC
output low-passed (tau ~100 ms), DC = 3.3 x 4.7/(4.7+50) ~ 0.28 V -> LOW.
Plug in: contact opens -> pull-up -> HIGH (HIGH = inserted).
Speaker amp MAX98357A
SD_MODE: GPIO24 10k / 1.8k -> ~0.50V = (L+R)/2 mono. Gain: open 9dB, A=6dB, B=12dB
JP1: 한쪽만 브리지할 것 — 양쪽 다 브리지하면 5V–GND 단락
(JP1: bridge ONE side only; both sides = 5V-GND short)
LCD / encoder / PWR_FLAG / holes
J6 VCC = +3V3 (2026-11-08):
encoder module pull-ups go to
its VCC; 5V would overdrive
the 3.3V-only Pi GPIOs.
J9 UART debug pads (no part fitted, DNP): 1=GND 2=UART_TX (Pi GPIO14 TXD) 3=UART_RX (Pi GPIO15 RXD) Net names from the Pi side. 3.3 V logic. 2026-11-08 A3
J10 button pads (DNP, no part fitted) 1=BTN (Pi GPIO4, J1 pin 7) 2=GND Switch to GND, Pi internal pull-up. 2026-11-12

Board: 2 copper layers, 63.5 x 70.0 mm, 83 parts (0 on the bottom side), 61 nets.

File PCB/kicad/radio-hat-v08/radio-hat-v08_bom.csv:

"Reference","Value","Footprint","LCSC","MPN","Qty"
"C1-C3,C5,C15,C21","10uF","Capacitor_SMD:C_0805_2012Metric","C15850","CL21A106KAYNNNE","6"
"C4,C11-C14,C22","0.1uF","Capacitor_SMD:C_0603_1608Metric","C14663","CC0603KRX7R9BB104","6"
"C6,C7,C25,C27","22uF","Capacitor_SMD:C_0805_2012Metric","C45783","CL21A226MAQNNNE","4"
"C8","220uF","Capacitor_SMD:CP_Elec_6.3x7.7","C970695","RVT1C221M0607","1"
"C9,C10","100nF","Capacitor_SMD:C_0603_1608Metric","C14663","CC0603KRX7R9BB104","2"
"C16-C18","2.2uF","Capacitor_SMD:C_0603_1608Metric","C23630","CL10A225KO8NNNC","3"
"C19,C20","2.2nF","Capacitor_SMD:C_0603_1608Metric","C1604","0603B222K500NT","2"
"C23,C24,C26","330pF","Capacitor_SMD:C_0603_1608Metric","C1664","CL10C331JB8NNNC","3"
"D1","SS34","Diode_SMD:D_SMA","C8678","SS34","1"
"D2","BLUE","radio-hat-v08:LED_XINGLIGHT_XL-1606_Horizontal","C965865","XL-1606UBC","1"
"D3","GREEN","radio-hat-v08:LED_XINGLIGHT_XL-1606_Horizontal","C965863","XL-1606UGC","1"
"D4","SMAJ5.0A","Diode_SMD:D_SMA","C2925443","SMAJ5.0A","1"
"FB1,FB2","FerriteBead","Inductor_SMD:L_0805_2012Metric","C85840","BLM21PG221SN1D","2"
"J1","Raspberry_Pi_40pin","radio-hat-v08:PinHeader_2x20_P2.54mm_Horizontal_PiSide","","","1"
"J2","USB_C_Receptacle_USB2.0_16P","Connector_USB:USB_C_Receptacle_HRO_TYPE-C-31-M-12","C165948","TYPE-C-31-M-12","1"
"J3","BAT","Connector_JST:JST_XH_S2B-XH-A_1x02_P2.50mm_Horizontal","C157931","S2B-XH-A(LF)(SN)","1"
"J4","PWR_SW","Connector_PinHeader_2.54mm:PinHeader_1x03_P2.54mm_Horizontal","C492411","PZ254R-11-03P","1"
"J5","LCD","Connector_PinHeader_2.54mm:PinHeader_1x08_P2.54mm_Horizontal","C492416","PZ254R-11-08P","1"
"J6","ENC","Connector_PinHeader_2.54mm:PinHeader_1x05_P2.54mm_Horizontal","C492413","PZ254R-11-05P","1"
"J7","SPK","Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Horizontal","C492410","PZ254R-11-02P","1"
"J8","PJ-307C","radio-hat-v08:Jack_3.5mm_PJ-307C_Horizontal","C16684","PJ-307C","1"
"L1","1uH","Inductor_SMD:L_Changjiang_FXL0420","C53426685","FXL0420-1R0-MA1","1"
"Q1","AO3401A","Package_TO_SOT_SMD:SOT-23","C15127","AO3401A","1"
"Q2","2N7002","Package_TO_SOT_SMD:SOT-23","C8545","2N7002","1"
"R1,R2","5.1k","Resistor_SMD:R_0603_1608Metric","C23186","0603WAF5101T5E","2"
"R3","1.2k","Resistor_SMD:R_0603_1608Metric","C22765","0603WAF1201T5E","1"
"R4,R5,R9","1k","Resistor_SMD:R_0603_1608Metric","C21190","0603WAF1001T5E","3"
"R6,R18,R21,R24","10k","Resistor_SMD:R_0603_1608Metric","C25804","0603WAF1002T5E","4"
"R7,R10,R13-R17","100k","Resistor_SMD:R_0603_1608Metric","C25803","0603WAF1003T5E","7"
"R8,R19,R20","100","Resistor_SMD:R_0603_1608Metric","C22775","0603WAF1000T5E","3"
"R11","510k","Resistor_SMD:R_0603_1608Metric","C23192","0603WAF5103T5E","1"
"R12","68k","Resistor_SMD:R_0603_1608Metric","C23231","0603WAF6802T5E","1"
"R22","1.8k","Resistor_SMD:R_0603_1608Metric","C4177","0603WAF1801T5E","1"
"R23","4.7k","Resistor_SMD:R_0603_1608Metric","C23162","0603WAF4701T5E","1"
"U1","TP4056","Package_SO:SOIC-8-1EP_3.9x4.9mm_P1.27mm_EP2.41x3.3mm","C16581","TP4056-42-ESOP8","1"
"U2","DW01A","Package_TO_SOT_SMD:SOT-23-6","C351410","DW01A","1"
"U3","WSP8814","Package_SO:TSSOP-8_4.4x3mm_P0.65mm","C148371","WSP8814","1"
"U4","TPS61023","Package_TO_SOT_SMD:SOT-563","C919459","TPS61023DRLR","1"
"U5","ADS1115IDGS","Package_SO:TSSOP-10_3x3mm_P0.5mm","C37593","ADS1115IDGSR","1"
"U6","PCM5102A","Package_SO:TSSOP-20_4.4x6.5mm_P0.65mm","C107671","PCM5102APWR","1"
"U7","MAX98357A","Package_DFN_QFN:TQFN-16-1EP_3x3mm_P0.5mm_EP1.23x1.23mm","C910544","MAX98357AETE+T","1"

## Commit log (part)

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2026-02-02 Edit run_radio.py
2026-02-13 add lcd_test.py
2026-02-13 Add main.py
2026-02-15 edit encoder pin out
2026-02-15 Edit main.py
2026-02-15 oled test
2026-02-15 Change file name
2026-02-15 Add README, add weathre infomation
2026-02-15 Add .gitignore and config.json.example
2026-02-16 Display update, Seperate files
2026-02-16 Remove __pycache__ and pyc files
2026-02-16 Edit .gitignore
2026-02-17 Save volume and backlight. Change way to enter blt mode
2026-02-18 Loading animation
2026-02-18 Display UTC time
2026-02-18 Vol 100% display OK
2026-02-20 LCD pin change
2026-02-20 Use audio
2026-02-25 Edit EQ, Add bat_test.py
2026-02-25 Display battery status, Fix weather update timing
2026-02-25 Weather display init time change
2026-02-26 Earphone insert check system
2026-02-28 Pam 모듈 교체 후 음량 테스트
2026-02-28 Edit player.py
2026-02-28 Add some tesets
2026-02-28 Max volume = 150
2026-02-28 LCD SPI update interval change (1.0)
2026-03-02 Fix pin numbers on lcd_test.py
2026-03-02 Add boot_greeting.py
2026-03-04 Add system setting menu with long press
2026-03-04 Menu 정리
2026-03-04 첫 시작시 배터리 측정 오류 수정
2026-03-04 Edit exit message
2026-03-04 Edit shutting down message
2026-03-06 Add BT test
2026-03-06 BT 기본 기능 구현
2026-03-06 BT 기능 개선
2026-03-07 BT scan 기능 확인
2026-04-02 Add PCB files
2026-04-30 PCB v0.5 수정 후 작동 확인, note 업데이트
2026-06-29 Case modeling
